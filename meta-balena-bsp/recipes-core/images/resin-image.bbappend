IMAGE_FSTYPES_append_qemuall = " resinos-img"
